# Keil uVision project project.uvprojx, settings and files
target rtthread-n32 (ARM-ADS)
  device: N32G452RCL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: N32G45X, USE_STDPERIPH_DRIVER, RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\msp;..\Libraries\rt_drivers;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\Libraries\N32_Std_Driver\CMSIS\core;..\Libraries\N32_Std_Driver\CMSIS\device;..\Libraries\N32_Std_Driver\n32g45x_std_periph_driver\inc;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: rt_drv_pwm.c pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: workqueue.c waitqueue.c pipe.c completion.c dataqueue.c ringblk_buf.c ringbuffer.c
  group Drivers
    board/msp/: n32_msp.c
    ../Libraries/N32_Std_Driver/CMSIS/device/startup/: startup_n32g45x.s
    board/: board.c
    ../Libraries/rt_drivers/: drv_gpio.c drv_usart.c drv_common.c drv_pwm.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: clock.c thread.c mempool.c scheduler.c device.c idle.c ipc.c timer.c mem.c irq.c object.c components.c kservice.c
  group libc
    ../../../components/libc/compilers/armlibc/: syscalls.c mem_std.c libc.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group Libraries
    ../Libraries/N32_Std_Driver/n32g45x_std_periph_driver/src/: n32g45x_rtc.c n32g45x_qspi.c n32g45x_sdio.c n32g45x_eth.c n32g45x_bkp.c n32g45x_dma.c n32g45x_usart.c n32g45x_adc.c n32g45x_dvp.c n32g45x_opamp.c misc.c n32g45x_spi.c n32g45x_dac.c n32g45x_exti.c n32g45x_gpio.c n32g45x_xfmc.c n32g45x_can.c n32g45x_pwr.c n32g45x_i2c.c n32g45x_wwdg.c n32g45x_dbg.c n32g45x_tim.c n32g45x_crc.c n32g45x_tsc.c n32g45x_iwdg.c n32g45x_rcc.c n32g45x_comp.c n32g45x_flash.c
    ../Libraries/N32_Std_Driver/CMSIS/device/: system_n32g45x.c
